## src/m_ble/Kconfig.ble
```kconfig
module = BLE_MODULE
module-str = Ble module
source "subsys/logging/Kconfig.template.log_config"
```
